# Wrynose's shadow-native configure test needs libcrypt in the native sysroot.
DEPENDS:append:class-native = " libxcrypt-native"
