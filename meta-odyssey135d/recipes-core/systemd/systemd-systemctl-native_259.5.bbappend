# systemd-systemctl-native checks for crypt.h during Meson configuration.
DEPENDS:append:class-native = " libxcrypt-native"
